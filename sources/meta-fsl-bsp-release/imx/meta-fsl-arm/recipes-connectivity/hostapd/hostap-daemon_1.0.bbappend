
NITSCRIPT_NAME = " "
INITSCRIPT_PARAMS = " "


PACKAGECONFIG += "gstreamer"

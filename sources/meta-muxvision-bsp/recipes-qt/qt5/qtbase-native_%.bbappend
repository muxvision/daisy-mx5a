PACKAGECONFIG_CONFARGS_remove = " \
    -no-sql-sqlite \
"
PACKAGECONFIG_CONFARGS_append = " \
    -sql-sqlite \
"

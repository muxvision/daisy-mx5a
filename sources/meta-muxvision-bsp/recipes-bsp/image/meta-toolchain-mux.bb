
CRIPTION = "Muxvision Image - Adds Qt5"
LICENSE = "MIT"

require recipes-qt/meta/meta-toolchain-qt5.bb
IMAGE_INSTALL += " \
"

RDEPENDS_${PN}_remove = "opencv-apps opencv-samples" 

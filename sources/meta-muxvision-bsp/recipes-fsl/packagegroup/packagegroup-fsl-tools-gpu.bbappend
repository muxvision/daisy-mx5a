SOC_TOOLS_GPU_remove_mx6 = " imx-gpu-sdk"

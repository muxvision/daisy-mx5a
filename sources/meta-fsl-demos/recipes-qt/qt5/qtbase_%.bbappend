SRC_URI_remove = "file://0001-evdevtouch-Avoid-crashing-on-exit.patch"

PACKAGECONFIG_DEFAULT_append = " \
    sql-sqlite \
"
